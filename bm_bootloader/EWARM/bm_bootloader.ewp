# IAR project bm_bootloader.ewp, settings and files
configuration bm_bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Src/board; ../Src/bootloader; ../Src/bootloader_if; ../Src/led; ../Src/flash_utils; ../Src/tm1629a; ../Src/serial; ../Src/circle_buffer; ../Src/debug/log; ../Src/debug/log/serial_uart; ../Src/debug/log/SEGGER_RTT_V612j/RTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: bm_bootloader.bin
  ILINK.IlinkOutputFile: bm_bootloader.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: gpio.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c main.c gpio.c iwdg.c spi.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/board
    ../Src/board/: board.c
  group Application/User/bootloader
    ../Src/bootloader/: bootloader.c
  group Application/User/bootloader_if
    ../Src/bootloader_if/: bootloader_if.c
  group Application/User/debug/log
    ../Src/debug/log/: log.c
  group Application/User/debug/log/segger_rtt
    ../Src/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Src/debug/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group Application/User/flash_utils
    ../Src/flash_utils/: flash_utils.c
  group Application/User/led
    ../Src/led/: led.c
  group Application/User/tm1629a
    ../Src/tm1629a/: tm1629a.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
